# IAR project project.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F1026A RL78 - R5F1026A
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 256
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: ..\App\; ..\BSP\; ..\CPU\; ..\CPU\FDLT04_V105_R5F102x6_IAR120\; ..\CPU\FDLT04_V105_R5F102x6_IAR120\lib\; ..\CPU\FDLT04_V105_R5F102x6_IAR120\smp\; ..\DOC\; ..\LIB\
  XLINK.XclFile: lnkr5f1026a.xcl
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: lnkr5f1026a.xcl
  group App
    ../App/: app.h main.c tag.c tag.h
  group BSP
    ../BSP/: bsp.h bsp_analog.c bsp_analog.h bsp_led.h bsp_measure.c bsp_measure.h bsp_nrf24l01p.c bsp_nrf24l01p.h bsp_power.c bsp_power.h bsp_rand.c bsp_rand.h bsp_syn.c bsp_syn.h bsp_timer.c bsp_timer.h bsp_wake.c bsp_wake.h
  group CPU
    ../CPU/: cpu.h r_cg.h r_cg_adc.c r_cg_adc.h r_cg_adc_user.c r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_intc.c r_cg_intc.h r_cg_intc_user.c r_cg_it.c r_cg_it.h r_cg_it_user.c r_cg_lvd.c r_cg_lvd.h r_cg_lvd_user.c r_cg_macrodriver.h r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_serial.c r_cg_serial.h r_cg_serial_user.c r_cg_timer.c r_cg_timer.h r_cg_timer_user.c r_cg_userdefine.h r_cg_wdt.c r_cg_wdt.h r_cg_wdt_user.c r_systeminit.c
  group DOC
    ../Doc/: LOG.txt PIN.txt
  group LIB
    ../LIB/: crc.c crc.h util.c util.h
