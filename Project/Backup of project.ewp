# IAR project Backup of project.ewp, settings and files
configuration Debug (RL78, debug)
  General.GenDeviceSelect: R5F10268 RL78 - R5F10268
  General.GenCodeModel: 0
  General.GenDataModel: 0
  General.GenStackSize: 256
  General.GenNearHeapSize: 256
  General.GenFarHeapSize: 4096
  ICCRL78.IccLang: 0
  ICCRL78.CCIncludePath2: ..\App\; ..\BSP\; ..\CPU\; ..\DOC\; ..\LIB\
  XLINK.XclFile: pfdl_sample_linker_file
  XLINK.XlinkStackSize: 1
configuration Release (RL78)
  as the first configuration, except:
  ICCRL78.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group App
    ../App/: app.h decode.c decode.h main.c
  group BSP
    ../BSP/: bsp.h bsp_analog.c bsp_analog.h bsp_nrf24l01p.c bsp_nrf24l01p.h bsp_test.h bsp_timer.c bsp_timer.h
  group CPU
    ../CPU/: cpu.h pfdl.c pfdl.h pfdl.inc pfdl_types.h r_cg.h r_cg_adc.c r_cg_adc.h r_cg_adc_user.c r_cg_cgc.c r_cg_cgc.h r_cg_cgc_user.c r_cg_it.c r_cg_it.h r_cg_it_user.c r_cg_macrodriver.h r_cg_port.c r_cg_port.h r_cg_port_user.c r_cg_serial.c r_cg_serial.h r_cg_serial_user.c r_cg_timer.c r_cg_timer.h r_cg_timer_user.c r_cg_userdefine.h r_cg_wdt.c r_cg_wdt.h r_cg_wdt_user.c r_systeminit.c
  group DOC
    ../Doc/: PIN.txt
  group LIB
    ../LIB/: crc.c crc.h
